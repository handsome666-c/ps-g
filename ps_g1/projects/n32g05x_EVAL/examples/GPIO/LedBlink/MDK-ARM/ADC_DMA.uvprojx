# Keil uVision project ADC_DMA.uvprojx, settings and files
target N32G05x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32G05xRB Nationstech
  pack: Nationstech.N32G05x_DFP.1.0.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x20000) IROM2(0x1FFF1000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ADC_DMA +hex
  AfterMake: fromelf --bin --output=.\bin\ADC_DMA.bin .\Objects\ADC_DMA.axf
  c flags: uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G05x, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32g05x_std_periph_driver\inc;..\ASW\ChargeManager;..\ASW\Charging;..\ASW\Cp;..\ASW\Diag;..\ASW\Diodecheck;..\ASW\factory;..\ASW\Led;..\ASW\Log;..\ASW\Precheck;..\ASW\Rly;..\ASW\Selfcheck;..\BSW\ComplexDrivers\AdFiter\ADCF;..\BSW\Mcalif\Adcif;..\RTE;..\rt_thread\include;..\BSW\ComplexDrivers\AdFiter\ADCM;..\BSW\Mcalif\NVIC;..\BSW\StorageService\Flashif;..\BSW\SystemService\EcuM;..\BSW\SystemService\N32_RT_Thread_Task;..\BSW\SystemService\WdgM;..\BSW\Mcalif\Portif;..\BSW\Mcalif\Adcif;..\BSW\Mcalif\Dioif;..\BSW\Mcalif\Pwmif;..\BSW\Mcalif\Timrif;..\BSW\Mcalif\Wdgif;..\BSW\Mcalif\Uartif;..\rt_thread\config;..\rt_thread\components\finsh
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT5: ROM 0x1fff1000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g05x.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g05x.c
  group FWLB
    ../../../../../../firmware/n32g05x_std_periph_driver/src/: n32g05x_gpio.c n32g05x_rcc.c n32g05x_adc.c misc.c n32g05x_dma.c n32g05x_tim.c n32g05x_uart.c n32g05x_wwdg.c n32g05x_pwr.c n32g05x_iwdg.c n32g05x_led.c n32g05x_beeper.c n32g05x_dac.c n32g05x_lcd.c n32g05x_spi.c n32g05x_can.c n32g05x_comp.c n32g05x_i2c.c n32g05x_flash.c n32g05x_exti.c n32g05x_dbg.c n32g05x_crc.c n32g05x_rtc.c
  group USER
    ../src/: main.c n32g05x_it.c
  group RT_Config
    ../rt_thread/config/: rtconfig.h
  group RT_libcpu
    ../rt_thread/libcpu/arm/cortex-m0/: context_rvds.S cpuport.c
  group RT_src
    ../rt_thread/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group RT_board
    ../rt_thread/board/: board.c
  group RT_finish
    ../rt_thread/components/finsh/: cmd.c msh.c shell.c ringbuf.c rtUart.c
  group RTE_BSW
    ../RTE/: RTE_ASW.c RTE_BSW.c
  group BSW_Mcalif
    ../BSW/Mcalif/Adcif/: Adcif.c
    ../BSW/Mcalif/Dioif/: Dioif.c Dioif_Cfg.c
    ../BSW/Mcalif/NVIC/: NVIC.c
    ../BSW/Mcalif/Portif/: Portif.c Portif_Cfg.c
    ../BSW/Mcalif/Pwmif/: Pwmif.c
    ../BSW/Mcalif/Timrif/: Timrif.c
    ../BSW/Mcalif/Uartif/: Uartif.c
    ../BSW/Mcalif/Wdgif/: Wdgif.c
  group BSW_SystemService
    ../BSW/SystemService/EcuM/: EcuM.c
    ../BSW/SystemService/N32_RT_Thread_Task/: N32_RT_Thread_Task.c
    ../BSW/SystemService/WdgM/: WdgM.c
  group BSW_StorageService
    ../BSW/StorageService/Flashif/: Flashif.c
  group BSW_ComplexDrivers
    ../BSW/ComplexDrivers/AdFiter/ADCF/: AdcF.c
    ../BSW/ComplexDrivers/AdFiter/ADCM/: AdcM.c AdcM_Cfg.c
  group ASW
    ../ASW/ChargeManager/: ChargeManager.c
    ../ASW/Charging/: Charging.c
    ../ASW/Cp/: cp.c
    ../ASW/Diag/: Diag.c
    ../ASW/Diodecheck/: Diodecheck.c
    ../ASW/factory/: factory.c
    ../ASW/Led/: Led.c
    ../ASW/Log/: Log.c
    ../ASW/Precheck/: Precheck.c
    ../ASW/Rly/: Rly.c
    ../ASW/Selfcheck/: Selfcheck.c
